# Keil uVision project StepPulse.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.2.3
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: StepPulse
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: AT32F403AVGT7,USE_STDPERIPH_DRIVER,AT_START_F403A_V1
  c include: ..\app;..\bsp;..\drivers;..\step\inc;..\step\inc\stepper_s_curve;..\system\inc;..\libraries\drivers\inc;..\libraries\cmsis\cm4\device_support;..\libraries\cmsis\cm4\core_support
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group device
    ../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
    ../libraries/cmsis/cm4/device_support/: system_at32f403a_407.c
  group system
    ../system/src/: at32f403a_407_clock.c at32f403a_407_int.c main.c at32_system_delay.c
  group fireware
    ../libraries/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group drivers
    ../drivers/: drv_gpio.c drv_goseiko.c
  group bsp
    ../bsp/: bsp_led.c bsp_time.c bsp_mPulse.c bsp_tpf.c
  group step
    ../step/src/: stepper_app.c
    ../step/src/stepper_s_curve/: func_plus.c func_plus_msp.c func_scrv.c s_curve_params.c
